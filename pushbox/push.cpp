#include "stdio.h"

int map[12][13] =
{
                {0,0,0,0,0,1,1,1,1,1,1,1,0},
                {0,0,0,0,0,1,0,0,1,0,0,1,0},
                {0,0,0,0,0,1,0,0,2,2,0,1,0},
                {1,1,1,1,1,1,0,2,1,0,0,1,0},
                {1,4,4,4,1,1,1,0,1,0,0,1,1},
                {1,4,0,0,1,0,0,2,0,1,0,0,1},
                {1,4,0,0,0,0,2,0,2,0,2,0,1},
                {1,4,0,0,1,0,0,2,0,1,0,0,1},
                {1,4,4,4,1,1,1,0,1,0,0,1,1},
                {1,1,1,1,1,1,0,2,0,0,0,1,0},
                {0,0,0,0,0,1,0,3,1,0,0,1,0},
                {0,0,0,0,0,1,1,1,1,1,1,1,0}
};

int main()
{
	for(int i = 0;i <12;i++)
	{
		for(int j = 0;j < 13;j++)
		{
			if(map[i][j] == 0)
			{
				printf(" ");
			}
			else if(map[i][j] == 1)
			{
				printf("☒");
			}
			else
			{
				printf(" ");
			}

		}
		printf("\n");
	}
	return 0;
}
